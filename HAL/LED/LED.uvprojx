# Keil uVision project LED.uvprojx, settings and files
target TM4C123x (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\..\LIBRARIES;..\..\MCAL\GPIO_API
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./: main.c LED_program.c LED_interface.h LED_config.h LED_private.h
    ../../MCAL/GPIO_API/: GPIO_config.h GPIO_interface.h GPIO_private.h GPIO_program.c
    ../../MCAL/Interrupt_Module/: INT_config.h INT_interface.h INT_private.h INT_progam.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
