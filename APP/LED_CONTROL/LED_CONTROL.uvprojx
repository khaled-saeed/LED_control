# Keil uVision project LED_CONTROL.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_CONTROL
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./: main.c LED_control.c LED_control.h
    ../../MCAL/GPIO_API/: GPIO_interface.h GPIO_config.h GPIO_private.h GPIO_program.c
    ../../MCAL/Interrupt_Module/: INT_interface.h INT_config.h INT_private.h INT_progam.c
    ../../MCAL/SYSTICK/: SYSTICK_interface.h SYSTICK_config.h SYSTICK_private.h SYSTICK_program.c
    ../../HAL/LED/: LED_config.h LED_interface.h LED_private.h LED_program.c
    ../../HAL/SWITCH/: SW_config.h SW_interface.h SW_private.h SW_program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
