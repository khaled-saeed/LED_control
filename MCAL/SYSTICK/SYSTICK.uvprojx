# Keil uVision project SYSTICK.uvprojx, settings and files
target TM4C123x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SYSTICK
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./: main.c SYSTICK_program.c SYSTICK_interface.h SYSTICK_config.h SYSTICK_private.h
    ../GPIO_API/: GPIO_config.h GPIO_interface.h GPIO_private.h GPIO_program.c
    ../Interrupt_Module/: INT_config.h INT_interface.h INT_private.h INT_progam.c
    ../../LIBRARIES/: bit_math.h STD_types.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
